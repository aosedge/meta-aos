SRC_URI = " \
    git://github.com/pocoproject/poco.git;branch=poco-1.12.5;protocol=https \
    file://0001-Use-std-atomic-int-instead-of-std-atomic-bool.patch \
    file://0001-cppignore.lnx-Ignore-PKCS12-and-testLaunch-test.patch \
    file://run-ptest \
    file://0002-fix-build-Install-cmake-files-with-resolved-ENABLE_J.patch \
"
