inherit core-image

require recipes-core/images/aos-image.inc
