FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://iptables.rules \
"
