SUMMARY = "nodejs layer"

require recipes-aos-layers/base-layer/base-layer.inc

AOS_LAYER_FEATURES += " \
    nodejs \
"

AOS_LAYER_VERSION = "1"
